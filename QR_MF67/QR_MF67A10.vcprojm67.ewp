# IAR project QR_MF67A10.vcprojm67.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEV_MF67; SOCKET_SUPPORT; DEV_MF67_A10
  ICCARM.CCIncludePath2: ..\..\..\sdk\inc; src; ..\..\..\sdk\inc\emv\inc; ..\..\..\sdk\inc\AppPub\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LCD_COLOR_1BIT
  OBJCOPY.OOCOutputFile: QR_MF67A10.bin
  ILINK.IlinkOutputFile: dev.out
  ILINK.IlinkIcfFile: settings\mf67A10_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib/driver
    ../../../sdk/driver/libpz04a/: FATFS.a FLASH_FAL.a IAR6_crypt_s_lib.a IAR6_MH1903S_MSR.a IAR_MH1903QRDecode.a MF_HAL.a UCOSII.a
  group lib/emv
    ../../../sdk/M90HLIB/: emvapi.a lib_amex.a lib_dpas.a lib_emv.a lib_emvpub.a lib_entry.a lib_paypass.a lib_quics.a lib_rupay.a lib_sibs.a lib_vcps.a
  group lib/system
    ../../../sdk/M90HLIB/: AppPub.a apppub2.a atc.a bluetooth.a json.a libapi_xpos.a libqr.a mbedtls.a mqtt_embed.a net.a power.a productTest.a rpc.a switchcheck.a tms.a wifi.a xgui.a
    ../../../sdk/M90HLIB/69R/: pub.a
  group set
    settings/: mf67A10_flash.icf
  group src
    src/test/: keySoundSet.c lcdLightSet.c test_pub.c
    src/: main.c mpos_func.c mpos_proc.c mpos_pub.c scan_page.c sdk_driver.c sdk_file.c sdk_http.c sdk_img.c sdk_log.c sdk_ntag.c sdk_showqr.c sdk_timer.c sdk_xgui.c upay_barscan.c
  group src/CJSON
    src/cJSON/: cJSON.c cJSON.h
  group src/mqtt
    src/mqtt/: mqtt_proc.c mqtt_proc.h
  group src/settings
    src/settings/: admin_set_func.c admin_set_func.h mqtt_set.c
