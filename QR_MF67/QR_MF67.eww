<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\QR_MF67A10.vcprojm67.ewp</path>
  </project>
  <batchBuild/>
</workspace>


